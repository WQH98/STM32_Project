# Keil uVision project template.uvprojx, settings and files
target template (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\USER;..\HAL_LIB\Inc;..\HARDWARE\clock;..\HARDWARE\led;..\HARDWARE\uart1;..\HARDWARE\key;..\HARDWARE\tim_interrupt;..\HARDWARE\tim_pwm;..\HARDWARE\tim_capture
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/clock/: clock.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/uart1/: uart.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/tim_interrupt/: tim_interrupt.c
    ../HARDWARE/tim_pwm/: tim_pwm.c
    ../HARDWARE/tim_capture/: tim_capture.c
  group CORE
    ../CORE/: startup_stm32f429xx.s
  group HAL_LIB
    ../HAL_LIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c

# Keil uVision project 08_FreeRTOS_LwIP_Test.uvprojx, settings and files
target 08_FreeRTOS_LwIP_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 08_FreeRTOS_LwIP_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\clock;..\HARDWARE\led;..\HARDWARE\uart;..\HARDWARE\iic;..\HARDWARE\pcf8574;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\lan8720;..\LwIP\arch;..\LwIP\lwip-2.1.0;..\LwIP;..\LwIP\lwip-2.1.0\src;..\LwIP\lwip-2.1.0\src\include;..\LwIP\lwip-2.1.0\src\include\compat;..\LwIP\lwip-2.1.0\src\include\lwip;..\LwIP\lwip-2.1.0\src\include\netif;..\LwIP\lwip-2.1.0\src\include\lwip\apps;..\LwIP\lwip-2.1.0\src\include\lwip\priv;..\LwIP\lwip-2.1.0\src\include\lwip\prot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_eth.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/clock/: clock.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/pcf8574/: pcf8574.c
    ../HARDWARE/lan8720/: lan8720.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LwIP_api
    ../LwIP/lwip-2.1.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_core
    ../LwIP/lwip-2.1.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/lwip-2.1.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP_netif
    ../LwIP/lwip-2.1.0/src/netif/: ethernet.c
  group LwIP_arch
    ../LwIP/arch/: ethernetif.c sys_arch.c
software components: CMSIS:CORE 4.3.0
